# Keil uVision project EFM32GG990F1024-KEIL.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EFM32GG990F1024 Silicon Labs
  pack: Keil.EFM32GGxxx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EFM32GG990F1024-KEIL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\EFM32GG990F1024-STK3700;..\..\platform\EFM32GG990F1024-STK3700\library\bsp;..\..\platform\EFM32GG990F1024-STK3700\library\emlib\inc;..\..\platform\EFM32GG990F1024-STK3700\library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\platform\EFM32GG990F1024-STK3700\STK3700-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group platform/stk3700
    ../../platform/EFM32GG990F1024-STK3700/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
    ../../platform/EFM32GG990F1024-STK3700/library/bsp/: segmentlcd.c retargetserial.c bsp_bcc.c bsp_stk.c bsp_stk_leds.c bsp_trace.c Buttons_STK3700.c LED_STK3700.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group user
    ../../user/: main.c
  group library/emlib
    ../../platform/EFM32GG990F1024-STK3700/library/emlib/src/: em_core.c em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_int.c em_lcd.c em_leuart.c em_msc.c em_system.c em_usart.c
  group startup
    ../../platform/EFM32GG990F1024-STK3700/: los_startup_keil.s
    ../../platform/EFM32GG990F1024-STK3700/library/emlib/src/: system_efm32gg.c
