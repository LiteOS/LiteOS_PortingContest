# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,RAM_SIZE_LEVEL_1
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\link\keil;..\..\platform\LOS_EXPAND_XXX;..\..\platform\LOS_EXPAND_XXX\Libraries\FWlib\inc;..\..\platform\LOS_EXPAND_XXX\Libraries\CMSIS;..\..\platform\LOS_EXPAND_XXX\local;..\..\example\include;..\..\kernel\cpu\arm\cortex-m3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\platform\LOS_EXPAND_XXX\local\Huawei_LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
    ../../platform/LOS_EXPAND_XXX/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
  group platfom/expand_xxx
    ../../platform/LOS_EXPAND_XXX/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group startup
    ../../platform/LOS_EXPAND_XXX/Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group user
    ../../user/: main.c
    ../../platform/LOS_EXPAND_XXX/local/: stm32f10x_conf.h
  group library
    ../../platform/LOS_EXPAND_XXX/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
