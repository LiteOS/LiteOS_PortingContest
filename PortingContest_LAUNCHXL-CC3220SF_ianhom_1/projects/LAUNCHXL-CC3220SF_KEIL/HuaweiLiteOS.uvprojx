# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LAUNCHXL_CC3220SF
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\LAUNCHXL-CC3220SF
  library: MicroLIB
  memory RVCT4: ROM 0x1000000 size 0x800
  memory RVCT5: ROM 0x1000800 size 0xff800
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\Objects\HuaweiLiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_keil.s los_hw.c los_hw.h los_hw_tick.c los_hwi.c los_hwi.h
  group platform/LAUNCHXL-CC3220SF
    ../../platform/LAUNCHXL-CC3220SF/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group user
    ../../user/: main.c
  group startup
    ../../platform/LAUNCHXL-CC3220SF/: los_startup_keil.s
