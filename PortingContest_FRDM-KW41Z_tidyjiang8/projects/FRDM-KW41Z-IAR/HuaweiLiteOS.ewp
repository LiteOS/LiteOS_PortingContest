# IAR project HuaweiLiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; FRDM_KW41Z; FREEDOM; _RTE_
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m0-plus; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\FRDM-KW41Z; ..\..\platform\FRDM-KW41Z\device; ..\..\platform\FRDM-KW41Z\drivers; ..\..\platform\FRDM-KW41Z\utilities; ..\..\platform\FRDM-KW41Z\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS.out
  ILINK.IlinkIcfFile: X:\port\PortingContest_FRDM-KW41Z_tidyjiang8\platform\FRDM-KW41Z\MKW41Z512xxx4_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m0+
    ../../kernel/cpu/arm/cortex-m0-plus/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/library
    ../../platform/FRDM-KW41Z/src/: clock_config.c
  group Huawei_LiteOS/library/drivers
    ../../platform/FRDM-KW41Z/drivers/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_cop.c fsl_dac.c fsl_dcdc.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_flash.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ltc.c fsl_ltc_edma.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rtc.c fsl_sim.c fsl_smc.c fsl_tpm.c fsl_trng.c fsl_tsi_v4.c fsl_vref.c
  group Huawei_LiteOS/library/utilities
    ../../platform/FRDM-KW41Z/utilities/: fsl_debug_console.c fsl_notifier.c fsl_sbrk.c
  group Huawei_LiteOS/platform/frdm-kw41z
    ../../platform/FRDM-KW41Z/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group Huawei_LiteOS/startup
    ../../platform/FRDM-KW41Z/device/: startup_MKW41Z4.s system_MKW41Z4.c
  group Huawei_LiteOS/user
    ../../user/: main.c
