# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ATSAM4SD32C Atmel
  pack: Keil.SAM4_DFP.1.5.0
  cpu: IROM(0x00400000,0x100000) IROM2(0x00500000,0x100000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ATSAM4S_XPRO,__SAM4SD32C__
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\ATSAM4S-XPRO
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x100000
  memory RVCT5: ROM 0x500000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: ..\..\platform\ATSAM4S-XPRO\ATSAM4S-XPRO-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/atsam4s-xpro
    ../../platform/ATSAM4S-XPRO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/ATSAM4S-XPRO/: los_startup_keil.s
  group user
    ../../user/: main.c
    ../../platform/ATSAM4S-XPRO/: system_SAM4S.c
software components: CMSIS:CORE 4.3.0
