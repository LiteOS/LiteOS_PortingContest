# IAR project HuaweiLiteOS_stm32f429.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m4; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\STM32F429I_DISCO
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_stm32f429.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS_stm32f429.out
  ILINK.IlinkIcfFile: ..\..\platform\STM32F429I_DISCO\STM32F429I-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/stm32f429i
    ../../platform/STM32F429I_DISCO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group Huawei_LiteOS/startup
    ../../platform/STM32F429I_DISCO/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c
