# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.12.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_NRF52840  NRF52840_XXAA CONFIG_GPIO_AS_PINRESET
  c include: ..\..\kernel\base\include;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\include;..\..\kernel\link\keil;..\..\example\include;..\..\platform\NRF52840-PDK;..\..\platform\NRF52840-PDK\config;..\..\platform\NRF52840-PDK\components\drivers_nrf\hal;..\..\platform\NRF52840-PDK\components\libraries\util;..\..\platform\NRF52840-PDK\components\drivers_nrf\nrf_soc_nosd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/NRF52840-PDK
    ../../platform/NRF52840-PDK/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/NRF52840-PDK/nRF52840_xxAA/: arm_startup_nrf52840.s system_nrf52840.c
  group user
    ../../user/: main.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
