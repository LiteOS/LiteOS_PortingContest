# Keil uVision project ATSAME70Q21.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IRAM(0x20400000,0x00060000) IROM(0x00400000,0x00200000) IROM2(0x00800000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ATSAME70Q21
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m7;..\..\platform\ATSAME70\BSP\Libraries\include;..\..\example\include;..\..\platform\ATSAME70;..\..\platform\ATSAME70\BSP\Libraries\include\component;..\..\platform\ATSAME70\BSP\Libraries\libchip\include;..\..\platform\ATSAME70\BSP\Libraries\include\instance;..\..\platform\ATSAME70\BSP\Libraries\include\pio;..\..\platform\ATSAME70\BSP\Libraries\libstoragemedia\include\sdmmc;..\..\platform\ATSAME70\BSP\Libraries\libusb\include;..\..\platform\ATSAME70\BSP\Libraries\libchip;..\..\platform\ATSAME70\BSP;..\..\platform\ATSAME70\BSP\include
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT5: ROM 0x800000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: ..\..\platform\ATSAME70\ATSAME70Q21-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m7
    ../../kernel/cpu/arm/cortex-m7/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group platform/atsame70
    ../../platform/ATSAME70/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group BSP/atsame70
    ../../platform/ATSAME70/BSP/: Buttons_SAME70-XPLD.c LED_SAME70-XPLD.c system_SAME70.c
    ../../platform/ATSAME70/BSP/Libraries/libchip/source/: pio.c pmc.c
    ../../platform/ATSAME70/BSP/source/: dbg_console.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/ATSAME70/: startup_SAME70.s
  group user
    ../../user/: main.c
